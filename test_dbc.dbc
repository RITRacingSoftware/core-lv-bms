// <Message Format> <CAN ID> <Message name> : <Data langth> <Transmitter name (optional)>

// <Signal syntax> <Signal name> : <Bit start position> | <Number of bits> <Big (0) vs Little (1) endian> <signed (-) vs unsigned (+)> (<scale>, <offset>)[<min val> | <max val>] <unit> <reciever name>

BO_ <ID> LVBMS_Voltages: 8 LVBMS
 SG_ LVBMS_Voltages_0 : 0|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Voltages_1 : 9|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Voltages_2 : 18|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ lVBMS_Voltages_3 : 27|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Voltages_4 : 36|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Voltages_5 : 45|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX

BO_ <ID> LVBMS_ChipVoltage: 8 LVBMS
 SG_ LVBMS_Chip_Voltage : 0|13@1+ (0.01,0) [0|30.72] "V" Vector__XXX             // correct max value?

BO_ <ID> LVBMS_Temperatures: 8 LVBMS
 SG_ LVBMS_Temperatures_0 : 0|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Temperatures_1 : 10|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Temperatures_2 : 20|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Temperatures_3 : 30|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Temperatures_4 : 40|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Temperatures_5 : 50|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX

BO_ <ID> LVBMS_ThermistorVoltages: 8 LVBMS                                       // where collected?
 SG_ LVBMS_ThermistorVoltages_0 : 3|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_ThermistorVoltages_1 : 12|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_ThermistorVoltages_2 : 21|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_ThermistorVoltages_3 : 30|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_ThermistorVoltages_4 : 39|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_ThermistorVoltages_5 : 48|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX

BO_ <ID> LVBMS_DrainStatus: 8 LVBMS                                              // required?
 SG_ LVBMS_DrainStatus_0 : 0|1@1+ (1,0) [0|1] "" Vector__XXX
 SG_ LVBMS_DrainStatus_1 : 1|1@1+ (1,0) [0|1] "" Vector__XXX
 SG_ LVBMS_DrainStatus_2 : 2|1@1+ (1,0) [0|1] "" Vector__XXX
 SG_ LVBMS_DrainStatus_3 : 3|1@1+ (1,0) [0|1] "" Vector__XXX
 SG_ LVBMS_DrainStatus_4 : 4|1@1+ (1,0) [0|1] "" Vector__XXX
 SG_ LVBMS_DrainStatus_5 : 5|1@1+ (1,0) [0|1] "" Vector__XXX

BO_ <ID> LVBMS_ChargeState: 8 LVBMS
 SG_ LVBMS_Status_ChargeState : 0|3@1+ (1,0) [0|7] "" Vector__XXX

BO_ <ID> LVBMS_CellOverview: 8 LVBMS                                             // required?
 SG_ LVBMS_Overview_VoltMin : 0|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Overview_VoltMax : 9|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Overview_VoltAvg : 18|9@1+ (0.01,0) [0|5.12] "V" Vector__XXX
 SG_ LVBMS_Overview_TempMin : 27|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Overview_TempMax : 37|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX
 SG_ LVBMS_Overview_TempAvg : 47|10@1+ (0.1,0) [0|102.3] "C" Vector__XXX

BO_ <ID> LVBMS_FaultVector: 8 LVBMS
 SG_ LVBMS_FaultVector_SHUTDOWN : 0|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_M17 : 1|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_ADES : 2|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_CELL_VOLT_IRR : 3|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_CHIP_VOLT_IRR : 4|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_TEMP_IRR : 5|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_OUT_OF_JUICE : 6|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_VOLTAGE_DIFF : 7|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_CHARGER : 8|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_OVERTEMP : 9|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_BALANCING : 10|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_OVERCURRENT : 11|1@1+ (1,0) [0|1] ""  Vector__XXX
 SG_ LVBMS_FaultVector_CURRENT_IRR : 12|1@1+ (1,0) [0|1] ""  Vector__XXX

BO_ <ID> LVBMS_ErrorCode: 8 LVBMS
 SG_ LVBMS_ErrorCode : 0|32@1+ (1,0) [0|0] ""  Vector__XXX                       // is this complete?

BO_ <ID> LVBMS_Current: 8 BMS                                                   
 SG_ BMS_InstCurrentFilt : 0|32@1- (0.001,0) [-100|250] "A"  DASH                // send to dash?